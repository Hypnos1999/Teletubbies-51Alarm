# Keil uVision project 51_Alarm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51_Alarm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SYSTEM\delay;..\HARDWARE\TIMER0;..\HARDWARE\TIMER1;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\DS1302;..\HARDWARE\EEPROM;..\HARDWARE\BEEP
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/TIMER0/: timer0.c
    ../HARDWARE/TIMER1/: timer1.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: display.c oled.c oledfont.c
    ../HARDWARE/DS1302/: ds1302.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/BEEP/: beep.c
